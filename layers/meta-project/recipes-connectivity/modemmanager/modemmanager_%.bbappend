# Enable modem protocol support that pulls in libmbim/libqmi dependencies.
PACKAGECONFIG:append = " mbim qmi"
