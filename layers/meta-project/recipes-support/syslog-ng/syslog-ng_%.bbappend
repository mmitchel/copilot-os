DEPENDS:append = " paho-mqtt-c"

EXTRA_OECONF:append = " --enable-mqtt"
